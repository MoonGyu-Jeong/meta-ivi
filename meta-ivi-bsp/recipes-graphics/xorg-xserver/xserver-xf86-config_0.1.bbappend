# Append path for meta-ivi layer to include bsp xorg.conf
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
